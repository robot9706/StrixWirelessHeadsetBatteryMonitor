# Keil uVision project heaphone_power_meter.uvprojx, settings and files
target nrf51422_xxac_s130 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s130 +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD S130 BOARD_PCA10028 NRF_LOG_USES_UART=1 SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0
  c include: ..\config\heaphone_power_meter;..\config;..\..\..\components\ble\common;..\..\..\components\drivers_nrf\common;..\..\..\components\drivers_nrf\config;..\..\..\components\drivers_nrf\delay;..\..\..\components\drivers_nrf\gpiote;..\..\..\components\drivers_nrf\hal;..\..\..\components\drivers_nrf\uart;..\..\..\components\drivers_nrf\adc;..\..\..\components\libraries\button;..\..\..\components\libraries\fifo;..\..\..\components\libraries\timer;..\..\..\components\libraries\uart;..\..\..\components\libraries\util;..\..\..\components\softdevice\common\softdevice_handler;..\..\..\components\softdevice\s130\headers;..\..\..\components\softdevice\s130\headers\nrf51;..\..\..\components\toolchain;..\..\..\examples\bsp;..\..\..\external\segger_rtt;.\
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x20001870 size 0x6790
  group Application
    ../: main.c uart.c
  group nRF_BLE
    ../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group nRF_Drivers
    ../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../components/drivers_nrf/adc/: nrf_drv_adc.c
  group nRF_Libraries
    ../../../components/libraries/util/: nrf_log.c app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../../components/libraries/button/: app_button.c
    ../../../components/libraries/fifo/: app_fifo.c
    ../../../components/libraries/timer/: app_timer.c
  group nRF_Segger_RTT
    ../../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../components/softdevice/s130/doc/: s130_nrf51_2.0.0_licence_agreement.txt
    ../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_s130_nrf51_2.0.0_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: as above
  output: s130_nrf51_2.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c include: ..\..\..\config\ble_app_beacon_s130_pca10028;..\..\..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x20001870 size 0x6790
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0
