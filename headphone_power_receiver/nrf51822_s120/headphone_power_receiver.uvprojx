# Keil uVision project headphone_power_receiver.uvprojx, settings and files
target nrf51422_xxac_s120 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.2
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51822_xxac_s120 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: __HEAP_SIZE=0 BLE_STACK_SUPPORT_REQD S120 BOARD_PCA10028 BSP_UART_SUPPORT NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --c99
  c include: ..\config;..\..\..\components\softdevice\s120\headers;..\..\..\components\ble\common;..\..\..\components\drivers_nrf\uart;..\..\..\components\ble\device_manager;..\..\..\components\device;..\..\..\components\toolchain;..\..\..\components\libraries\util;..\..\..\components\libraries\fifo;..\..\..\components\drivers_nrf\gpiote;..\..\..\components\drivers_nrf\config;..\..\..\components\drivers_nrf\common;..\..\..\components\drivers_nrf\hal;..\..\..\components\libraries\button;..\..\..\components\softdevice\common\softdevice_handler;..\..\..\components\libraries\timer;..\..\..\components\libraries\trace
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1d000 size 0x23000
  memory RVCT9: RAM 0x20002800 size 0x5800
  group Application
    ../: main.c uart.c
  group nRF_BLE
    ../../../components/ble/common/: ble_advdata.c
  group nRF_Drivers
    ../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
  group nRF_Libraries
    ../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../components/libraries/fifo/: app_fifo.c
    ../../../components/libraries/timer/: app_timer.c
  group nRF_SoftDevice
    ../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.2
  cpu: as above
  output: s120_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: __HEAP_SIZE=0 BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..\..\..\config
  asm define: __HEAP_SIZE=0 BLE_STACK_SUPPORT_REQD
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 3.40.0, Device:Startup 7.2.1
